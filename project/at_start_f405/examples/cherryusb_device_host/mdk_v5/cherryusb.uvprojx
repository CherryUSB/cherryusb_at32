# Keil uVision project cherryusb.uvprojx, settings and files
target cherryusb (6140001::V6.14.1::ARMCLANG)
  device: AT32F405RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.1.2
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: winusb_hs +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F405RCT7,USE_STDPERIPH_DRIVER,AT_START_F405_V1
  c include: ..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\at32f402_405_board;..\inc;..\..\..\..\..\cherryusb\common;..\..\..\..\..\cherryusb\core;..\..\..\..\..\cherryusb\class\cdc;..\..\..\..\..\cherryusb\class\msc;..\..\..\..\..\cherryusb\class\hub;..\..\..\..\..\cherryusb\class\hid;..\..\..\..\..\cherryusb\class\video;..\..\..\..\..\cherryusb\class\audio;..\..\..\..\..\middlewares\freertos\source\include;..\..\..\..\..\middlewares\freertos\source\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
  group user
    ../src/: at32f402_405_clock.c at32f402_405_int.c main.c msc_ram_template.c
    ../../../../../cherryusb/demo/: usb_host.c
  group bsp
    ../../../../at32f402_405_board/: at32f402_405_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f402_405_acc.c at32f402_405_crm.c at32f402_405_exint.c at32f402_405_gpio.c at32f402_405_misc.c at32f402_405_pwc.c at32f402_405_scfg.c at32f402_405_tmr.c at32f402_405_usart.c at32f402_405_usb.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f402_405.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f402_405.s
  group cherryusb
    ../../../../../cherryusb/core/: usbh_core.c usbd_core.c
    ../../../../../cherryusb/class/hid/: usbh_hid.c usbd_hid.c
    ../../../../../cherryusb/class/cdc/: usbh_cdc_acm.c usbd_cdc_acm.c
    ../../../../../cherryusb/class/hub/: usbh_hub.c
    ../../../../../cherryusb/class/msc/: usbh_msc.c usbd_msc.c
    ../../../../../cherryusb/osal/: usb_osal_freertos.c
    ../../../../../cherryusb/port/dwc2/: usb_glue_at.c usb_hc_dwc2.c usb_dc_dwc2.c
  group freertos
    ../../../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../middlewares/freertos/source/portable/GCC/ARM_CM4F/: port.c
    ../../../../../middlewares/freertos/source/portable/memmang/: heap_4.c
target winusb_fs (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F405RCT7 ArteryTek
  pack: ArteryTek.AT32F402_405_DFP.2.1.2
  output: winusb_fs +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F405RCT7,USE_STDPERIPH_DRIVER,AT_START_F405_V1,USB_OTG_FS
  c include: ..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\at32f402_405_board;..\inc;..\..\..\..\..\middlewares\usb_drivers\inc;..\..\..\..\..\middlewares\usbd_class\winusb
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x19800
